# Keil uVision project Fortior_FU6511.uvproj, settings and files
target Fortior_6511_SVPWM (MCS-51)
  device: FU6512_62 Fortior Tech
  cpu: IRAM(0-0xFF) CLOCK(24000000)
  output: Fortior_FU6511 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\FU68xx_Hardware_Driver\Include;..\User\Include
  link misc: REMOVEUNUSED
  group Application
    ../User/Source/Application/: main.c Interrupt.c AddFunction.c
    ../User/Include/: Customer.h
  group Function
    ../User/Source/Function/: MotorControl.c MotorControlFunction.c MotorProtect.c PIControl.c TailWind.c AdativeLeadAngle.c SquStart.LIB
  group HardWare
    ../User/Source/Hardware/: OVCP.c ADC.c AMP.c DRIVER.c GPIO.c CMP.c TIMER.c Key_Driver.c UART.c FU6511_Flash.c
  group FU68XX_Hardware_Driver
    ../FU68xx_Hardware_Driver/Source/: STARTUP_FU6816.A51
